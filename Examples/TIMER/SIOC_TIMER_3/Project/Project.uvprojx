# Keil uVision project Project.uvprojx, settings and files
target PWM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\INC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../Source/: main.c stm32f10x_it.c
    ./: stm32f10x_vector.s
  group source
    ../Source/: PWM.c
  group LIB
    ../LIB/: STM32F10xR.LIB
software components: CMSIS:CORE 5.0.1
